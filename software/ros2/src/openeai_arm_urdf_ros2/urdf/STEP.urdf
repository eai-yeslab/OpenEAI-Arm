Commit message: feat: improve gravity computation for arm

File: software/ros2/src/openeai_arm_urdf_ros2/urdf/STEP.urdf (robot description, URDF)
Before this commit: robot STEP, 7 links, 6 joints
Links:
- link link6: mass 0.63362 -> 0.83362
